Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Número de proyecto
Time: 2016-06-09T16:50:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 15.6.0.0 - Alternate UI 15.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jun 09 16:50:34 2016 * Host: BICHO-B03 * Database: C:\Users\JORDIG~1\AppData\Local\Temp\{F60D079E-DA39-4E32-BC55-9EAFF44B3E96}\ifc * Database version: 5507 * Database creation date: Thu Jun 09 16:50:34 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jun 09 16:50:34 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jun 09 16:50:34 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Número de proyecto
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 40, 25, 0, 86975; RefLongitude: -3, -42, -1, -243858; RefElevation: 0 m
Otros - Categoría: Información de proyecto; Dirección de proyecto: Introduzca dirección aquí; Estado de proyecto: Estado de proyecto; Fecha de emisión de proyecto: Fecha de emisión; Nombre de cliente: Propietario; Nombre de proyecto: Nombre de proyecto; Número de proyecto: Número de proyecto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Otros - Categoría: Información de proyecto; Dirección de proyecto: Introduzca dirección aquí; Estado de proyecto: Estado de proyecto; Fecha de emisión de proyecto: Fecha de emisión; Nombre de cliente: Propietario; Nombre de proyecto: Nombre de proyecto; Número de proyecto: Número de proyecto

# IfcBuildingStorey, Nivel 1
LongName: Nivel 1; Elevation: 0 m
Restricciones - Altura base: Punto base del proyecto; Alzado: 0 m
Otros - Categoría: Niveles; Nombre de familia: Nivel; Familia: Nivel: Nivel 1; Familia y tipo: Nivel: Nivel 1; ID de tipo: Nivel: Nivel 1; Tipo: Nivel: Nivel 1
Cotas - Altura de cálculo: 0 m
Datos de identidad - Estructura: no; Nombre: Nivel 1; Planta de edificio: yes; Nombre de tipo: Nivel 1
Gráficos - Color: 0; Grosor de línea: 1; Patrón de línea: Trazo punto; Símbolo: Extremo de nivel: Extremo de nivel; Símbolo en extremo 1 por defecto: no; Símbolo en extremo 2 por defecto: yes

# IfcBuildingElementProxy: Eurocondens SGB 400, 2014_Caldera_Baxi_de-Gas-de-Condensación-Eurocondens-SGB-400-610:Eurocondens SGB 400:154507
In: Nivel 1
Type - Material: Aleación aluminio-silicio acabado pintura - Baxi, Display - Baxi, Cristal Display - Baxi
Type - Cotas - A-Espacio de Seguridad Recomendado: 0.8 m; Altura (mm): 1.371 m; Ancho (mm): 0.762 m; B-Espacio de Seguridad Recomendado: 0.5 m; C-Espacio de Seguridad Recomendado (Derecha): 0.15 m; C-Espacio de Seguridad Recomendado (Izquierda): 0.8 m; D-Espacio de Seguridad Recomendado: 0.3 m; Diametro Interior Entrada de Aire (mm): 0.16 m; Diametro Interior Gas (mm): 0.054 m; Diametro Interior IC-RC (mm): 0.08 m; Diametro Interior Salida de Humos (mm): 0.25 m; Diametro Interior Válvula Seguridad (mm): 0.054 m; Largo (mm): 1.882 m
Type - Datos - Capacidad agua: 0.073 m3; Longitud máx. evacuación de humos (m): 0.05 m; Peso neto aproximado: 540; Potencia útil 50/30 ºC: 426000 W; Potencia útil 80/60 ºC: 393800 W; Presión máxima de trabajo: 600000 Pa; Rendimiento útil (1) con carga 100%: 1.065; Rendimiento útil (1) con carga 30%: 1.066; Rendimiento útil (2) con carga 100%: 0.98; Tipo de gas: natural
Type - Datos de identidad - Autor: Bimetica Parametric Design Services S.L.; Bimetica: http://www.bimetica.com; Catálogo tarifa: http://www.baxi.es/docs/sp_cataleg/CatSept16_EuroCondens_SGB_gas.pdf; Declaración de conformidad CE: http://www.baxi.es/docs/sp_decla/Decla_CE_Eurocondens_SGB.pdf; Descripción: Calderas de fundición de 125 kW de potencia útil, para instalaciones de Calefacción por agua caliente hasta 6 bar. Posibilidad integral de conexión doble en cascada homologada como un único generador.; EmailContacto: solutions@baxi.es; Fabricante: Baxi Calefacción, S.L.U.; FechaEmisionElementoBIM: 14/04/2016; FechaVencimientoElementoBIM: 01/01/2017; Folleto media potencia: http://www.baxi.es/docs/sp_folleta/folleto_MediaPotencia2015.pdf; Homologación: http://www.baxi.es/docs/sp_homo/homo_eurocondensSGB.pdf; Manual Instalador: http://www.baxi.es/docs/sp_instruc/SGB400-610_H_BAXI.pdf; Modelo: Eurocondens SGB 400; Nombre de tipo: Eurocondens SGB 400; Número OmniClass: 23.75.00.00; NumeroSerie: Eurocondens SGB; Referencia: Eurocondens SGB 400; ReferenciaContacto: Departamento Técnico; TelefonoContacto: 902 89 89 89; Título OmniClass: Climate Control (HVAC); URL: www.baxi.es; URLProducto: http://www.baxi.es/docs/sp_folleta/Folleto_EuroCondens_SGB_2013_BAXI.pdf
Type - Materiales y acabados - Carcasa: Aleación aluminio-silicio acabado pintura - Baxi; Display: Display - Baxi; Pantalla: Cristal Display - Baxi; Requerimiento de Espacio Recomendado: Requerimiento Espacio Recomendado
Type - Mecánica - Flujo Entrada Aire: 0 m3/s; Flujo Gas: 0 m3/s; Flujo Humo: 0 m3/s; Flujo Ida - Agua: 0 m3/s; Flujo Retorno - Agua: 0 m3/s
Type - Otros - Categoría: Equipos mecánicos; Altura Conexiones: 1.526 m; Altura Tubo F: 1.481 m; B: 0.28 m; C: 0.505 m; D-C: 1.251 m; Diametro Exterior Gas: 0.064 m; Diametro Exterior IC-RC: 0.09 m; Diametro Exterior Válvula Seguridad: 0.064 m; E: 0.66 m; E-1: 0.391 m; E-2: 0.214 m; F Exterior: 0.27 m; G: 1.223 m; H: 0.365 m; I: 0.25 m; K: 0.08 m; L: 0.45 m; M: 0.441 m; N: 0.642 m; Nombre de familia: 2014_Caldera_Baxi_de-Gas-de-Condensación-Eurocondens-SGB-400-610; SGB 125: no; SGB 170: no; SGB 215: no; SGB 260: no; SGB 300: no; SGB 400: yes; SGB 470: no; SGB 540: no; SGB 610: no; Situación Gas: 0.32 m
Pset_BuildingElementProxyCommon - Reference: Eurocondens SGB 400
Pset_ManufacturerTypeInformation - Manufacturer: Baxi Calefacción, S.L.U.
Cotas - Área: 19.4133 m2; Volumen: 1.97112 m3
Datos de identidad - Marca: 3
Mecánica - Clasificación de sistema: Ventilación,Suministro hidrónico,Retorno hidrónico,Otro,Ventilación; Espacio de Seguridad Recomendado: no
Otros - Familia: 2014_Caldera_Baxi_de-Gas-de-Condensación-Eurocondens-SGB-400-610: Eurocondens SGB 400; Familia y tipo: 2014_Caldera_Baxi_de-Gas-de-Condensación-Eurocondens-SGB-400-610: Eurocondens SGB 400; ID de tipo: 2014_Caldera_Baxi_de-Gas-de-Condensación-Eurocondens-SGB-400-610: Eurocondens SGB 400; Tipo: 2014_Caldera_Baxi_de-Gas-de-Condensación-Eurocondens-SGB-400-610: Eurocondens SGB 400
Proceso por fases - Fase de creación: Nueva construcción
Restricciones - Anfitrión: Nivel : Nivel 1; Desfase: 0 m; Nivel: Nivel: Nivel 1
