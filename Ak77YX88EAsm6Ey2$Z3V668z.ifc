Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Número de proyecto
Time: 2016-06-09T16:54:35
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 15.6.0.0 - Alternate UI 15.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jun 09 16:54:35 2016 * Host: BICHO-B03 * Database: C:\Users\JORDIG~1\AppData\Local\Temp\{A047EEA4-A5F2-423D-B441-27E2C78BED8B}\ifc * Database version: 5507 * Database creation date: Thu Jun 09 16:54:35 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jun 09 16:54:35 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jun 09 16:54:35 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Número de proyecto
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 40, 25, 0, 86975; RefLongitude: -3, -42, -1, -243858; RefElevation: 0 m
Otros - Categoría: Información de proyecto; Dirección de proyecto: Introduzca dirección aquí; Estado de proyecto: Estado de proyecto; Fecha de emisión de proyecto: Fecha de emisión; Nombre de cliente: Propietario; Nombre de proyecto: Nombre de proyecto; Número de proyecto: Número de proyecto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Otros - Categoría: Información de proyecto; Dirección de proyecto: Introduzca dirección aquí; Estado de proyecto: Estado de proyecto; Fecha de emisión de proyecto: Fecha de emisión; Nombre de cliente: Propietario; Nombre de proyecto: Nombre de proyecto; Número de proyecto: Número de proyecto

# IfcBuildingStorey, Nivel 1
LongName: Nivel 1; Elevation: 0 m
Restricciones - Altura base: Punto base del proyecto; Alzado: 0 m
Otros - Categoría: Niveles; Nombre de familia: Nivel; Familia: Nivel: Nivel 1; Familia y tipo: Nivel: Nivel 1; ID de tipo: Nivel: Nivel 1; Tipo: Nivel: Nivel 1
Cotas - Altura de cálculo: 0 m
Datos de identidad - Estructura: no; Nombre: Nivel 1; Planta de edificio: yes; Nombre de tipo: Nivel 1
Gráficos - Color: 0; Grosor de línea: 1; Patrón de línea: Trazo punto; Símbolo: Extremo de nivel: Extremo de nivel; Símbolo en extremo 1 por defecto: no; Símbolo en extremo 2 por defecto: yes

# IfcBuildingElementProxy: Eurocondens SGB 260, 2014_Caldera_Baxi_de-Gas-de-Condensación-Eurocondens-SGB-125-300:Eurocondens SGB 260:155971
In: Nivel 1
Type - Material: Aleación aluminio-silicio acabado pintura - Baxi, Display - Baxi, Cristal Display - Baxi
Type - Cotas - A-Espacio de Seguridad Recomendado: 0.9 m; Altura (mm): 1.389 m; Ancho (mm): 0.692 m; B-Espacio de Seguridad Recomendado: 0.5 m; C-Espacio de Seguridad Recomendado (Derecha): 0.5 m; C-Espacio de Seguridad Recomendado (Izquierda): 0.5 m; D-Espacio de Seguridad Recomendado: 0.1 m; Diametro Interior Entrada de Aire (mm): 0.125 m; Diametro Interior Gas (mm): 0.042 m; Diametro Interior IC-RC (mm): 0.065 m; Diametro Interior Salida de Humos (mm): 0.2 m; Diametro Interior Válvula Seguridad (mm): 0.035 m; Largo (mm): 1.264 m
Type - Datos - Capacidad agua: 0.045 m3; Longitud máx. evacuación de humos (m): 0.06 m; Peso neto aproximado: 314; Potencia útil 50/30 ºC: 278100 W; Potencia útil 80/60 ºC: 254500 W; Presión máxima de trabajo: 600000 Pa; Rendimiento útil (1) con carga 100%: 1.07; Rendimiento útil (1) con carga 30%: 1.07; Rendimiento útil (2) con carga 100%: 0.979; Tipo de gas: natural/propano
Type - Datos de identidad - Autor: Bimetica Parametric Design Services S.L.; Bimetica: http://www.bimetica.com; Catálogo tarifa: http://www.baxi.es/docs/sp_cataleg/CatSept16_EuroCondens_SGB_gas.pdf/; Declaración de conformidad CE: http://www.baxi.es/docs/sp_decla/Decla_CE_Eurocondens_SGB.pdf; Descripción: Calderas de fundición de 125 kW de potencia útil, para instalaciones de Calefacción por agua caliente hasta 6 bar. Posibilidad integral de conexión doble en cascada homologada como un único generador.; EmailContacto: solutions@baxi.es; Fabricante: Baxi Calefacción, S.L.U.; FechaEmisionElementoBIM: 14/04/2016; FechaVencimientoElementoBIM: 01/01/2017; Folleto media potencia: http://www.baxi.es/docs/sp_folleta/folleto_MediaPotencia2015.pdf; Homologación: http://www.baxi.es/docs/sp_homo/homo_eurocondensSGB.pdf; Manual Instalador: http://www.baxi.es/docs/sp_instruc/SGB125-300H.pdf; Manual Usuario: http://www.baxi.es/docs/sp_instruc/SGB125-300_H_BAXI.pdf; Modelo: Eurocondens SGB 260; Nombre de tipo: Eurocondens SGB 260; Número OmniClass: 23.75.00.00; NumeroSerie: Eurocondens SGB; Referencia: Eurocondens SGB 260; ReferenciaContacto: Departamento Técnico; TelefonoContacto: 902 89 89 89; Título OmniClass: Climate Control (HVAC); URL: www.baxi.es; URLProducto: http://www.baxi.es/docs/sp_folleta/Folleto_EuroCondens_SGB_2013_BAXI.pdf
Type - Materiales y acabados - Carcasa: Aleación aluminio-silicio acabado pintura - Baxi; Display: Display - Baxi; Pantalla: Cristal Display - Baxi; Requerimiento de Espacio Recomendado: Requerimiento Espacio Recomendado
Type - Mecánica - Flujo Entrada Aire: 0 m3/s; Flujo Gas: 0 m3/s; Flujo Humo: 0 m3/s; Flujo Ida - Agua: 0 m3/s; Flujo Retorno - Agua: 0 m3/s
Type - Otros - Categoría: Equipos mecánicos; Altura Conexiones: 1.444 m; Altura Tubo F: 1.444 m; B: 0.28 m; C: 0.351 m; D-C: 0.958 m; Diametro Exterior Gas: 0.052 m; Diametro Exterior IC-RC: 0.075 m; Diametro Exterior Válvula Seguridad: 0.045 m; E: 0.122 m; E-1: 0.302 m; E-2: 0.163 m; F Exterior: 0.22 m; G: 0.944 m; H: 0.365 m; I: 0.25 m; K: 0.08 m; L: 0.45 m; M: 0.167 m; N: 0.32 m; Nombre de familia: 2014_Caldera_Baxi_de-Gas-de-Condensación-Eurocondens-SGB-125-300; SGB 125: no; SGB 170: no; SGB 215: no; SGB 260: yes; SGB 300: no; SGB 400: no; SGB 470: no; SGB 540: no; SGB 610: no; Situación Gas: 0.096 m
Pset_BuildingElementProxyCommon - Reference: Eurocondens SGB 260
Pset_ManufacturerTypeInformation - Manufacturer: Baxi Calefacción, S.L.U.
Cotas - Área: 15.1131 m2; Volumen: 1.21726 m3
Datos de identidad - Marca: 4
Mecánica - Clasificación de sistema: Ventilación,Suministro hidrónico,Retorno hidrónico,Otro,Ventilación,Otro; Espacio de Seguridad Recomendado: no
Otros - Familia: 2014_Caldera_Baxi_de-Gas-de-Condensación-Eurocondens-SGB-125-300: Eurocondens SGB 260; Familia y tipo: 2014_Caldera_Baxi_de-Gas-de-Condensación-Eurocondens-SGB-125-300: Eurocondens SGB 260; ID de tipo: 2014_Caldera_Baxi_de-Gas-de-Condensación-Eurocondens-SGB-125-300: Eurocondens SGB 260; Tipo: 2014_Caldera_Baxi_de-Gas-de-Condensación-Eurocondens-SGB-125-300: Eurocondens SGB 260
Proceso por fases - Fase de creación: Nueva construcción
Restricciones - Anfitrión: Nivel : Nivel 1; Desfase: 0 m; Nivel: Nivel: Nivel 1
