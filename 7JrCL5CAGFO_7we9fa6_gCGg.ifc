Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-10-25T12:31:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180216_1515(x64) - Exporter 19.0.0.405 - IU alternativa 19.0.0.405
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 25 12:31:50 2018 * Host: ES-D-0262 * Database: C:\Users\jmarce\AppData\Local\Temp\{B2C1CBAB-699C-40F5-82C7-E06AE35DD9DD}\ifc * Database version: 5507 * Database creation date: Thu Oct 25 12:31:48 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 25 12:31:48 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 25 12:31:48 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 40, 25, 13, 9643; RefLongitude: -3, -42, -20, -772056; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Nivel 2
LongName: Nivel 2; Elevation: 4000 mm

# IfcFlowStorageDevice: BC BIBLOC iPlus iMPH/H 6MR (UI), BAXI_PLATINUM BC_SPLIT_iPlus_iMPI-H_(UI):BC BIBLOC iPlus iMPH/H 6MR (UI):137963
In: Nivel 2
Type - PredefinedType: EXPANSION; Material: BAXI_Chapa, BAXI_Cobre, BAXI_Logo, BAXI_LCD, BAXI_Plástico, BAXI_Espacio Instalación/Mantenimiento
Pset_DistributionFlowElementCommon - Reference: BC BIBLOC iPlus iMPH/H 6MR (UI)
Pset_ManufacturerTypeInformation - Manufacturer: BAXI
