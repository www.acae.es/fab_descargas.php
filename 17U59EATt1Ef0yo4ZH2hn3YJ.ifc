Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-10-25T15:14:32
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180216_1515(x64) - Exporter 19.0.0.405 - IU alternativa 19.0.0.405
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 25 15:14:32 2018 * Host: ES-D-0262 * Database: C:\Users\jmarce\AppData\Local\Temp\{49C72F3E-473C-4041-9CD2-EA6118B5DD84}\ifc * Database version: 5507 * Database creation date: Thu Oct 25 15:14:32 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 25 15:14:32 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 25 15:14:32 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 40, 25, 13, 9643; RefLongitude: -3, -42, -20, -772056; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Nivel 2
LongName: Nivel 2; Elevation: 4000 mm

# IfcFlowStorageDevice: BC ACS SPLIT 300 (UI), BAXI_BC_ACS_SPLIT_200-300_(UI_Acumulador):BC ACS SPLIT 300 (UI):137845
In: Nivel 2
Type - Material: BAXI_Gris, BAXI_Logo, BAXI_Acero esmaltado, BAXI_Rojo, BAXI_Negro, BAXI_Azul, BAXI_Espacio Instalación/Mantenimiento
Pset_DistributionFlowElementCommon - Reference: BC ACS SPLIT 300 (UI)
Pset_ManufacturerTypeInformation - Manufacturer: BAXI
