Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2016-06-09T16:54:41
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140223_1515(x64) - Exporter 15.6.0.0 - Alternate UI 15.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jun 09 16:54:41 2016 * Host: Bestia-01 * Database: C:\Users\CARLOS~1\AppData\Local\Temp\{49A0000E-9D10-47B8-92FE-1D4D546F82C0}\ifc * Database version: 5507 * Database creation date: Thu Jun 09 16:54:41 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jun 09 16:54:41 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jun 09 16:54:41 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 40, 23, 59, 999999; RefLongitude: -3, -40, -59, -879999; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: 0001; Project Status: Estado de proyecto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: 0001; Project Status: Estado de proyecto

# IfcBuildingStorey, Nivel 1
LongName: Nivel 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Extremo inicial 8 mm; Family and Type: Level: Extremo inicial 8 mm; Type: Level: Extremo inicial 8 mm; Type Id: Level: Extremo inicial 8 mm
Identity Data - Type Name: Extremo inicial 8 mm; Building Story: yes; Name: Nivel 1; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: Extremo inicial de nivel - Círculo: Extremo inicial de nivel - Círculo; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: 50 F, 2014_Caldera_Baxi_de-Gas-de-Condensación-Bios-Plus:50 F:136085
In: Nivel 1
Type - Material: Cristal Display - Baxi, Aleación aluminio-silicio acabado pintura - Baxi, Conexión, Display - Baxi
Type - Data - Capacidad agua: 0.004 m3; Clase de eficiencia en calefacción (ErP): A; Longitud máx. conducto concéntrico (mm): 10000 mm; Longitud máx. conducto doble (mm): 60000 mm; Peso neto aproximado: 40; Potencia útil 50/30 ºC: 48600 W; Potencia útil 80/60 ºC: 45000 W; Presión máxima de trabajo: 400000 Pa; Rendimiento útil (50/30ºC) con carga 100%: 1.078; Rendimiento útil (50/30ºC) con carga 30%: 1.05; Rendimiento útil (80/60ºC) con carga 100%: 0.974; Tipo de gas: natural/propano
Type - Dimensions - Alto (mm): 763 mm; Altura Situación Caldera (mm): 1000 mm; Ancho (mm): 450 mm; Diámetro Interior - Conexión de gas (mm): 25 mm; Diametro Interior - EA-1 (mm): 125 mm; Diametro Interior - EA-2 (mm): 80 mm; Diametro Interior - MR Impulsión Calefacción (Agua Caliente) (mm): 28 mm; Diametro Interior - RR Retorno Calefacción (Agua Fría) (mm): 28 mm; Diámetro Interior - Salida condensados (mm): 21 mm; Diametro Interior - SH (mm): 80 mm; Largo (mm): 377 mm
Type - Identity Data - Autor: Bimetica Parametric Design Services S.L.; Bimetica: http://www.bimetica.com; Catálogo tarifa: http://www.baxi.es/docs/sp_cataleg/CatSept16_BiosPlus.pdf; Declaración de conformidad CE: http://www.baxi.es/docs/sp_decla/CE_DECLARATION_BIOS_PLUS.PDF; Description: Estas calderas murales de condensación se distinguen por se elevada potencia y eficiencia concentrada en un reducido volumen. Como cualquier caldera de condensación, tiene un elevado rendimiento que alcanza 109,8% y son Clase 5 de NOx. Esto implica que son calderas con una combustión ecológica y que tienen un consumo de gas muy inferior al de una caldera convencional de potencia similar. Destacan también por su elevada versatilidad. Gracias a los accesorios opcionales de conexión hidráulica y a los diferentes dispositivos de regulación pueden trabajar individualmente o conjuntamente mediante una conexión en cascada de varias. Esto permite que se puedan acoplar a cualquier tipo de instalación para ofrecer calefacción y agua caliente sanitaria.; EmailContacto: solutions@baxi.es; FechaEmisionElementoBIM: 03/05/2016; FechaVencimientoElementoBIM: 01/01/2017; Folleto media potencia: http://www.baxi.es/docs/sp_folleta/folleto_MediaPotencia2015.pdf; Homologación: http://www.baxi.es/docs/sp_homo/CE-0085CM0128_ROCA_BIOS_PLUS.pdf; Manual Instalador: http://www.baxi.es/docs/sp_instruc/SGB125-300H.pdf/; Manual Usuario: http://www.baxi.es/docs/sp_instruc/SGB125-300_H_BAXI.pdf/; Manufacturer: Baxi Calefacción, S.L.U.; Model: BIOS PLUS 50 F; NumeroSerie: BIOS PLUS; Referencia: BIOS PLUS 50 F; ReferenciaContacto: Departamento Técnico; TelefonoContacto: 902 89 89 89; Type Name: 50 F; URL: www.baxi.es; URLProducto: http://www.baxi.es/biosplus/
Type - Materials and Finishes - Carcasa: Aleación aluminio-silicio acabado pintura - Baxi; Conexiones: Conexión; Display: Cristal Display - Baxi; Frontal: Display - Baxi
Type - Mechanical - Flujo Condensados: 0 m3/s; Flujo Entrada Aire: 0 m3/s; Flujo Gas: 0 m3/s; Flujo Humo: 0 m3/s; Flujo MR Impulsión calefacción (Agua Caliente): 0 m3/s; Flujo RR Retorno calefacción (Agua fría): 0 m3/s
Type - Other - Category: Mechanical Equipment; 110 F: no; 50 F: yes; 70 F: no; 90 F: no; Conexiones Inferiores - Situación: 95 mm; D: 3.85742 mm; Diametro Exterior - EA-1: 130 mm; Diametro Exterior - EA-2: 85 mm; Diametro Exterior - Gas: 29 mm; Diametro Exterior - MR Impulsión Calefacción (Agua Caliente): 32 mm; Diametro Exterior - RR Retorno Calefacción (Agua Fría): 32 mm; Diametro Exterior - SH: 88 mm; EA-1 Situación: 225 mm; EA-1 Situación 2: 225 mm; EA-2 Situación: 225 mm; EA-2 Situación 2: 100 mm; Family Name: 2014_Caldera_Baxi_de-Gas-de-Condensación-Bios-Plus; Gas - Situación: 79 mm; MR - Situación: 100 mm; Purgador - Situación: 275 mm; Purgador - Situación 2: 100 mm; RR - Situación: 100 mm; SC - Situación: 67 mm; SC - Situación 2: 48 mm
Pset_BuildingElementProxyCommon - Reference: 50 F
Pset_ManufacturerTypeInformation - Manufacturer: Baxi Calefacción, S.L.U.
Cantidades de equipos mecánicos - Descripción de unidad: 2014_Caldera_Baxi_de-Gas-de-Condensación-Bios-Plus: 50 F; Tipo: 2014_Caldera_Baxi_de-Gas-de-Condensación-Bios-Plus: 50 F; Descripción: Estas calderas murales de condensación se distinguen por se elevada potencia y eficiencia concentrada en un reducido volumen. Como cualquier caldera de condensación, tiene un elevado rendimiento que alcanza 109,8% y son Clase 5 de NOx. Esto implica que son calderas con una combustión ecológica y que tienen un consumo de gas muy inferior al de una caldera convencional de potencia similar. Destacan también por su elevada versatilidad. Gracias a los accesorios opcionales de conexión hidráulica y a los diferentes dispositivos de regulación pueden trabajar individualmente o conjuntamente mediante una conexión en cascada de varias. Esto permite que se puedan acoplar a cualquier tipo de instalación para ofrecer calefacción y agua caliente sanitaria.; Fabricante: Baxi Calefacción, S.L.U.; Modelo: BIOS PLUS 50 F; URL: www.baxi.es
Constraints - Elevation: 973.332 mm; Level: Level: Nivel 1
Dimensions - Area: 0.848224 m2; Volume: 0.129575 m3
Identity Data - Mark: 4
Mechanical - System Classification: Vent,Other,Hydronic Supply,Hydronic Return
Other - Family: 2014_Caldera_Baxi_de-Gas-de-Condensación-Bios-Plus: 50 F; Family and Type: 2014_Caldera_Baxi_de-Gas-de-Condensación-Bios-Plus: 50 F; Host Id: Basic Wall: Exterior - Ladrillo en entramado metálico; Type: 2014_Caldera_Baxi_de-Gas-de-Condensación-Bios-Plus: 50 F; Type Id: 2014_Caldera_Baxi_de-Gas-de-Condensación-Bios-Plus: 50 F
Phasing - Phase Created: Fase 1
