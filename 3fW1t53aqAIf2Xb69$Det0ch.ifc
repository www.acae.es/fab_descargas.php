Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Número de proyecto
Time: 2016-06-09T16:47:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 15.6.0.0 - Alternate UI 15.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jun 09 16:47:53 2016 * Host: BICHO-B03 * Database: C:\Users\JORDIG~1\AppData\Local\Temp\{03CE7539-6A99-4568-BF3E-44414CB4532A}\ifc * Database version: 5507 * Database creation date: Thu Jun 09 16:47:53 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jun 09 16:47:53 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jun 09 16:47:53 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Número de proyecto
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 40, 25, 0, 86975; RefLongitude: -3, -42, -1, -243858; RefElevation: 0 m
Otros - Categoría: Información de proyecto; Dirección de proyecto: Introduzca dirección aquí; Estado de proyecto: Estado de proyecto; Fecha de emisión de proyecto: Fecha de emisión; Nombre de cliente: Propietario; Nombre de proyecto: Nombre de proyecto; Número de proyecto: Número de proyecto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Otros - Categoría: Información de proyecto; Dirección de proyecto: Introduzca dirección aquí; Estado de proyecto: Estado de proyecto; Fecha de emisión de proyecto: Fecha de emisión; Nombre de cliente: Propietario; Nombre de proyecto: Nombre de proyecto; Número de proyecto: Número de proyecto

# IfcBuildingStorey, Nivel 1
LongName: Nivel 1; Elevation: 0 m
Restricciones - Altura base: Punto base del proyecto; Alzado: 0 m
Otros - Categoría: Niveles; Nombre de familia: Nivel; Familia: Nivel: Nivel 1; Familia y tipo: Nivel: Nivel 1; ID de tipo: Nivel: Nivel 1; Tipo: Nivel: Nivel 1
Cotas - Altura de cálculo: 0 m
Datos de identidad - Estructura: no; Nombre: Nivel 1; Planta de edificio: yes; Nombre de tipo: Nivel 1
Gráficos - Color: 0; Grosor de línea: 1; Patrón de línea: Trazo punto; Símbolo: Extremo de nivel: Extremo de nivel; Símbolo en extremo 1 por defecto: no; Símbolo en extremo 2 por defecto: yes

# IfcBuildingElementProxy: EcoTherm Plus WGB 50, 2014_Caldera_Baxi_Mural-de-Gas-de-Condensación_EcoTherm-Plus-WGB:EcoTherm Plus WGB 50:153149
In: Nivel 1
Type - Material: Display - Baxi - Blanco, Display - Baxi - Negro, Conexión, Aleación aluminio-silicio acabado pintura - Baxi
Type - Cotas - Alto (mm): 0.851 m; Ancho (mm): 0.48 m; B: 0.168 m; C: 0.132 m; Diámetro Interior - Conexión de gas: 0.028 m; Diámetro Interior - Entrada de aire: 0.16 m; Diámetro Interior - Impulsión calefacción (Agua Caliente): 0.042 m; Diámetro Interior - Retorno calefacción (Agua fría): 0.042 m; Diámetro Interior - Salida condensados: 0.025 m; Diámetro Interior - Salida de humos: 0.11 m; Largo (mm): 0.447 m
Type - Datos - Capacidad agua: 0.0047 m3; Clase de eficiencia en calefacción (ErP): A; Longitud máx. conducto concéntrico (m): 0.025 m; Longitud máx. conducto doble (m): 0.023 m; Peso neto aproximado: 61; Potencia útil 50/30 ºC: 51900 W; Potencia útil 80/60 ºC: 48500 W; Presión máxima de trabajo: 4 Pa; Rendimiento útil (40/30ºC) con carga 30%: 1.073; Rendimiento útil (70/50ºC) con carga 100%: 0.993; Tipo de gas: natural/propano
Type - Datos de identidad - Autor: Bimetica Parametric Design Services S.L.; Bimetica: http://www.bimetica.com; Catálogo tarifa: http://www.baxi.es/docs/sp_cataleg/CatSept16_EcoThermPlusWGBH.pdf; Comentarios de tipo: Las calderas de condensación de gas EcoTherm Plus WGB con potencias de 28 a 110 kW y posibilidad de instalación de hasta 15 calderas en cascada, constituyen una solución silenciosa, segura y fiable, tanto para edificios de viviendas como para viviendas unifamiliares. Prevista para la producción de calefacción y agua caliente sanitaria por acumulación, la caldera EcoTherm Plus WGB basa su funcionamiento en la tecnología de la condensación, empleando gas como combustible. Esta eficaz combinación proporciona un funcionamiento silencioso, altamente eficiente y con un nivel de emisiones contaminantes muy por debajo de los requisitos mínimos exigidos por la normativa actual.; Declaración de conformidad CE: http://www.baxi.es/docs/CE_Ecotherm_Plus_WGB.pdf; Descripción: Caldera mural de condensación EcoTherm Plus WGB; EmailContacto: solutions@baxi.es; Fabricante: Baxi Calefacción, S.L.U.; FechaEmisionElementoBIM: 03/05/2016; FechaVencimientoElementoBIM: 01/01/2017; Folleto media potencia: http://www.baxi.es/docs/sp_folleta/folleto_MediaPotencia2015.pdf; Homologación: http://www.baxi.es/docs/sp_homo/homo_wgbh.pdf; Manual Instalador: http://www.baxi.es/docs/sp_instruc/Manual_Instalacion_WGB_50_110_H_BAXI.pdf; Manual Usuario: http://www.baxi.es/docs/sp_instruc/Manual_Instrucciones_WGB_50_110_H_BAXI.pdf; Modelo: EcoTherm Plus WGB 50; Nombre de tipo: EcoTherm Plus WGB 50; Número OmniClass: 23.75.00.00; NumeroSerie: EcoTherm Plus WGB; Referencia: EcoTherm Plus WGB 50; ReferenciaContacto: Departamento Técnico; TelefonoContacto: 902 89 89 89; Título OmniClass: Climate Control (HVAC); URL: www.baxi.es; URLProducto: http://www.baxi.es/7650/
Type - Materiales y acabados - Caracasa: Aleación aluminio-silicio acabado pintura - Baxi; Conexiones: Conexión; Frontal 1: Display - Baxi - Blanco; Frontal 2: Display - Baxi - Negro
Type - Mecánica - Flujo Condensados: 0 m3/s; Flujo Entrada Aire: 0 m3/s; Flujo Gas: 0 m3/s; Flujo Humo: 0 m3/s; Flujo Impulsión calefacción (Agua Caliente): 0 m3/s; Flujo Retorno calefacción (Agua fría): 0 m3/s
Type - Otros - Categoría: Equipos mecánicos; Diámetro Exterior - Conexión de gas: 0.031 m; Diámetro Exterior - Entrada de aire: 0.165 m; Diámetro Exterior - Impulsión calefacción (Agua Caliente): 0.045 m; Diámetro Exterior - Retorno calefacción (Agua fría): 0.045 m; Diámetro Exterior - Salida condensados: 0.028 m; Diámetro Exterior - Salida de humos: 0.115 m; Longitud máx. conducto concéntrico (mm): 25 m; Longitud máx. conducto doble (mm): 23 m; Nombre de familia: 2014_Caldera_Baxi_Mural-de-Gas-de-Condensación_EcoTherm-Plus-WGB; WGB 110: no; WGB 50: yes; WGB 70: no; WGB 90: no
Pset_BuildingElementProxyCommon - Reference: EcoTherm Plus WGB 50
Pset_ManufacturerTypeInformation - Manufacturer: Baxi Calefacción, S.L.U.
Cotas - Área: 1.15325 m2; Volumen: 0.187011 m3
Datos de identidad - Marca: 2
Mecánica - Clasificación de sistema: Ventilación,Otro,Suministro hidrónico,Retorno hidrónico,Otro
Otros - Familia: 2014_Caldera_Baxi_Mural-de-Gas-de-Condensación_EcoTherm-Plus-WGB: EcoTherm Plus WGB 50; Familia y tipo: 2014_Caldera_Baxi_Mural-de-Gas-de-Condensación_EcoTherm-Plus-WGB: EcoTherm Plus WGB 50; ID de tipo: 2014_Caldera_Baxi_Mural-de-Gas-de-Condensación_EcoTherm-Plus-WGB: EcoTherm Plus WGB 50; Tipo: 2014_Caldera_Baxi_Mural-de-Gas-de-Condensación_EcoTherm-Plus-WGB: EcoTherm Plus WGB 50
Proceso por fases - Fase de creación: Nueva construcción
Restricciones - Anfitrión: Nivel : Nivel 1; Desfase: 0 m; Nivel: Nivel: Nivel 1
